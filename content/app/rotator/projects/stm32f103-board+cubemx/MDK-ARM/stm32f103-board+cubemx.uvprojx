# Keil uVision project stm32f103-board+cubemx.uvprojx, settings and files
target stm32f103-board+cubemx (6070000::V6.7::.\ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103-board+cubemx +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;            C:/reference/cubmx-fm-location/STM32Cube_FW_F1_V1.8.0/Drivers/STM32F1xx_HAL_Driver/Inc;            C:/reference/cubmx-fm-location/STM32Cube_FW_F1_V1.8.0/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;            C:/reference/cubmx-fm-location/STM32Cube_FW_F1_V1.8.0/Drivers/CMSIS/Device/ST/STM32F1xx/Include;            C:/reference/cubmx-fm-location/STM32Cube_FW_F1_V1.8.0/Drivers/CMSIS/Include;            ..\..\..\..\..\reference\robosd-ref\content\robosd;            ..\..\..\..\..\reference\robosd-ref\content\robosd\core\platform\keil5+cpp11;            ..\..\..\source\common;            ..\..\..\source\platform\stm32f103-board+cubemx;            ..\..\..\source\common\vercion\default
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group source/common
    ../../../source/common/: robosd.cpp robosd.hpp board.flow.common.h board_common.h free_master_cfg_tuning.h mexo_options.h rotator.hpp rotator.cpp
  group source/platform
    ../../../source/platform/stm32f103-board+cubemx/: rotator_perefery.cpp
  group source/common/vercion/default
    ../../../source/common/vercion/default/: robosd_app_tuning.h board_options.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c rtc.c tim.c usart.c usb.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/reference/cubmx-fm-location/STM32Cube_FW_F1_V1.8.0/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.3.0
